# Repository cozycactus/goa-console (continued)

## KiCad design master.kicad_pcb (continued)

Schematic: 18_headphones.kicad_sch, HEADPHONES, METER L

Parts:
C147: 2.2u film; C_Rect_L7.2mm_W7.2mm_P5.00mm_FKS2_FKP2_MKS2_MKP2; MPN KEMET MMK5225K63J06L4BULK (PET 63V; rep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
C148, C156: 22p C0G; C_0805_2012Metric; MPN KEMET C0805C220J5GACTU
C149, C150: 100n; C_0805_2012Metric; MPN Samsung CL21B104KBCNNNC (X7R 50V)
C151, C152: 10u NP 25V; CP_Radial_D5.0mm_P2.00mm; MPN Panasonic ECE-A1EN100U
C153: 100p C0G; C_0805_2012Metric; MPN KEMET C0805C101J5GACTU
D22, D23, D24: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal; MPN Vishay 1N4148-TAP
K6: G6K-2F-Y DC12; Relay_DPDT_Omron_G6K-2F-Y; MPN Omron G6K-2F-Y DC12
R133: 100K; R_0805_2012Metric
R134: 2R2; R_2512_6332Metric; MPN Vishay CRCW25122R20FKEGHP
R135: 4K7; R_0805_2012Metric
R136: 2K2; R_0805_2012Metric
R137: 560R; R_0805_2012Metric
R138: 100R; R_0805_2012Metric
R139, R140, R142, R143: 10K; R_0805_2012Metric
R141: 20K; R_0805_2012Metric
R171: 120R; R_0805_2012Metric
RV7: Cal 10K; Potentiometer_Bourns_3296W_Vertical; MPN Bourns 3296W-1-103LF
U26: OPA1612; SOIC-8_3.9x4.9mm_P1.27mm; MPN TI OPA1612AIDR
U28: LME49600; TO-263-5_TabPin3; MPN TI LME49600TS/NOPB
U29: TL072; SOIC-8_3.9x4.9mm_P1.27mm; MPN TI TL072HIDR

Connections:
+VBUS: R137.1; also elsewhere on the board
+VM: R171.1; also elsewhere on the board
+VP: C149.1, C151.1, U28.5 (V+); also elsewhere on the board
-VP: C150.2, C152.2, U28.3 (V-); also elsewhere on the board
CRSB_L: R138.1; also elsewhere on the board
GNDM: U29.3 (+), U29.5 (+); also elsewhere on the board
MLA_QE: R171.2; also elsewhere on the board
ML_HW: D23.2 (A), R140.2, R142.1
ML_X2: C156.1, R143.1, U29.7; also elsewhere on the board
MTR_L: R138.2, R139.1, R141.1; also elsewhere on the board
unnamed: D22.1 (K), K6.1, R137.2
unnamed: D23.1 (K), D24.2 (A), U29.1
unnamed: D24.1 (K), R139.2, R140.1, U29.2 (-)
unnamed: R134.1, U28.4
unnamed: R143.2, RV7.1
unnamed: C147.2, C148.1, R133.1, U26.5 (+)
unnamed: C153.2, R135.2, R136.1, U26.6 (-)
unnamed: C153.1, U26.7, U28.2 (IN)
unnamed: C156.2, R141.2, R142.2, RV7.2, RV7.3, U29.6 (-)
PHJ_L: K6.3; also elsewhere on the board
PHJ_R: K6.6; also elsewhere on the board
PHONESGND: K6.2, K6.7; also elsewhere on the board
PHO_L: K6.4; also elsewhere on the board
PHO_R: K6.5, R134.2, R135.1
PHW_R: C147.1; also elsewhere on the board
RLY_DRV: D22.2 (A), K6.8; also elsewhere on the board

Notes on the sheet:
HEADPHONES: PHONES dual A10K, OPA1612 + LME49600 composite (+9.9 dB), 2R2 out, mute relay, PHONESGND (cont.)
METER L: full-wave rectifier, precision peak / average, follower (TL072), 2 dB ladder, 2 x 10-LED strings

Schematic: 19_meter_l.kicad_sch, METER L

Parts:
C157: 2.2u film; C_Rect_L7.2mm_W7.2mm_P5.00mm_FKS2_FKP2_MKS2_MKP2; MPN KEMET MMK5225K63J06L4BULK (PET 63V; rep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
C160: 1u; C_1206_3216Metric; MPN Samsung CL31B105KBHNNNE (X7R 50V)
C161: 22p C0G; C_0805_2012Metric; MPN KEMET C0805C220J5GACTU
D25, D26, D27, D28, D39, D40: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal; MPN Vishay 1N4148-TAP
JP1: PEAK(1-2) / AVG; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
R144: 33K; R_0805_2012Metric
R145, R159: 220R; R_0805_2012Metric
R146: 330K; R_0805_2012Metric
R147: 220K; R_0805_2012Metric
R148: 10K; R_0805_2012Metric
R149, R156: 470R; R_0805_2012Metric
R150: 16K; R_0805_2012Metric
R151: 1K5; R_0805_2012Metric
R152: 1K1; R_0805_2012Metric
R153: 910R; R_0805_2012Metric
R154: 680R; R_0805_2012Metric
R155: 620R; R_0805_2012Metric
R157: 330R; R_0805_2012Metric
R158: 300R; R_0805_2012Metric
R160: 180R; R_0805_2012Metric
R161: 150R; R_0805_2012Metric
R162: 110R; R_0805_2012Metric
R163, R170: 91R; R_0805_2012Metric
R164: 68R; R_0805_2012Metric
R165: 62R; R_0805_2012Metric
R166: 47R; R_0805_2012Metric
R167: 33R; R_0805_2012Metric
R168: 27R; R_0805_2012Metric
R169: 20R; R_0805_2012Metric
R172, R174: 27K; R_0805_2012Metric
R173: 120R; R_0805_2012Metric
U30: TL072; SOIC-8_3.9x4.9mm_P1.27mm; MPN TI TL072HIDR

Connections:
+VM: D27.2 (A), D39.2 (A), R150.1, R173.1; also elsewhere on the board
-VM: R172.2, R174.2; also elsewhere on the board
GNDM: C157.2, C160.2, R147.2, R170.2; also elsewhere on the board
MLA_QB: D28.1 (K), R172.1; also elsewhere on the board
MLB_QB: D40.1 (K), R174.1; also elsewhere on the board
MLB_QE: R173.2; also elsewhere on the board
ML_DET: R149.2; also elsewhere on the board
ML_DETO: R148.1, R149.1, U30.6 (-), U30.7
ML_T1: R169.2, R170.1; also elsewhere on the board
ML_T2: R168.2, R169.1; also elsewhere on the board
ML_T3: R167.2, R168.1; also elsewhere on the board
ML_T4: R166.2, R167.1; also elsewhere on the board
ML_T5: R165.2, R166.1; also elsewhere on the board
ML_T6: R164.2, R165.1; also elsewhere on the board
ML_T7: R163.2, R164.1; also elsewhere on the board
ML_T8: R162.2, R163.1; also elsewhere on the board
ML_T9: R161.2, R162.1; also elsewhere on the board
ML_T10: R160.2, R161.1; also elsewhere on the board
ML_T11: R159.2, R160.1; also elsewhere on the board
ML_T12: R158.2, R159.1; also elsewhere on the board
ML_T13: R157.2, R158.1; also elsewhere on the board
ML_T14: R156.2, R157.1; also elsewhere on the board
ML_T15: R155.2, R156.1; also elsewhere on the board
ML_T16: R154.2, R155.1; also elsewhere on the board
ML_T17: R153.2, R154.1; also elsewhere on the board
ML_T18: R152.2, R153.1; also elsewhere on the board
ML_T19: R151.2, R152.1; also elsewhere on the board
ML_T20: R150.2, R151.1; also elsewhere on the board
ML_X2: R144.1, U30.3 (+); also elsewhere on the board
unnamed: C160.1, R145.2, R146.1
unnamed: C161.1, D25.2 (A), D26.1 (K), U30.1
unnamed: D25.1 (K), JP1.1 (A), R145.1
unnamed: C161.2, D26.2 (A), R148.2, U30.2 (-)
unnamed: D27.1 (K), D28.2 (A)
unnamed: D39.1 (K), D40.2 (A)
unnamed: C157.1, JP1.3 (B), R144.2
unnamed: JP1.2 (C), U30.5 (+)
unnamed: R146.2, R147.1

Notes on the sheet:
METER L: full-wave rectifier, precision peak / average, follower (TL072), 2 dB ladder, 2 x 10-LED strings (cont.)

Schematic: 20_meter_l.kicad_sch, METER L

Parts:
C154, C155: 100n; C_0805_2012Metric; MPN Samsung CL21B104KBCNNNC (X7R 50V)
D29: green -20 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
D30: green -18 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
D31: green -16 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
D32: green -14 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
D33: green -12 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
D34: green -10 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
D35: green -8 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
D36: green -6 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
D37: green -4 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
D38: green -2 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
Q2: BCP53-16; SOT-223; MPN onsemi BCP53-16T1G
R173: 120R; R_0805_2012Metric
U29: TL072; SOIC-8_3.9x4.9mm_P1.27mm; MPN TI TL072HIDR
U31, U32, U33: LM2901; SOIC-14_3.9x8.7mm_P1.27mm; MPN TI LM2901BIDR

Connections:
+VM: C154.1, R173.1, U29.8 (V+); also elsewhere on the board
-VM: C155.2, D38.1 (K), U29.4 (V-); also elsewhere on the board
GNDM: C154.2, C155.1; also elsewhere on the board
MLA_5: D33.1 (K), D34.2 (A), U32.1
MLA_QB: Q2.1 (B); also elsewhere on the board
MLA_QE: Q2.3 (E); also elsewhere on the board
MLB_QE: R173.2; also elsewhere on the board
ML_DET: U31.5 (+), U31.7 (+), U31.9 (+), U31.11 (+), U32.5 (+), U32.7 (+), U32.9 (+), U32.11 (+), U33.5 (+), U33.7 (+); also elsewhere on the board
ML_T1: U31.4 (-); also elsewhere on the board
ML_T2: U31.6 (-); also elsewhere on the board
ML_T3: U31.10 (-); also elsewhere on the board
ML_T4: U31.8 (-); also elsewhere on the board
ML_T5: U32.4 (-); also elsewhere on the board
ML_T6: U32.6 (-); also elsewhere on the board
ML_T7: U32.10 (-); also elsewhere on the board
ML_T8: U32.8 (-); also elsewhere on the board
ML_T9: U33.4 (-); also elsewhere on the board
ML_T10: U33.6 (-); also elsewhere on the board
unnamed: D29.2 (A), Q2.2 (C), Q2.4 (C), U31.2
unnamed: D29.1 (K), D30.2 (A), U31.1
unnamed: D30.1 (K), D31.2 (A), U31.13
unnamed: D31.1 (K), D32.2 (A), U31.14
unnamed: D32.1 (K), D33.2 (A), U32.2
unnamed: D34.1 (K), D35.2 (A), U32.13
unnamed: D35.1 (K), D36.2 (A), U32.14
unnamed: D36.1 (K), D37.2 (A), U33.2
unnamed: D37.1 (K), D38.2 (A), U33.1

Notes on the sheet:
METER L: full-wave rectifier, precision peak / average, follower (TL072), 2 dB ladder, 2 x 10-LED strings (cont.)

Schematic: 21_meter_l.kicad_sch, METER L

Parts:
C158, C159, C162, C163, C164, C165, C166, C167, C168, C169, C170, C171: 100n; C_0805_2012Metric; MPN Samsung CL21B104KBCNNNC (X7R 50V)
D39, D40: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal; MPN Vishay 1N4148-TAP
R174: 27K; R_0805_2012Metric
U30: TL072; SOIC-8_3.9x4.9mm_P1.27mm; MPN TI TL072HIDR
U31, U32, U33, U34, U35: LM2901; SOIC-14_3.9x8.7mm_P1.27mm; MPN TI LM2901BIDR

Connections:
+VM: C158.1, C162.1, C164.1, C166.1, C168.1, C170.1, D39.2 (A), U30.8 (V+), U31.3 (V+), U32.3 (V+), U33.3 (V+), U34.3 (V+), U35.3 (V+); also elsewhere on the board
-VM: C159.2, C163.2, C165.2, C167.2, C169.2, C171.2, R174.2, U30.4 (V-), U31.12 (V-), U32.12 (V-), U33.12 (V-), U34.12 (V-), U35.12 (V-); also elsewhere on the board
GNDM: C158.2, C159.1, C162.2, C163.1, C164.2, C165.1, C166.2, C167.1, C168.2, C169.1, C170.2, C171.1; also elsewhere on the board
MLB_QB: D40.1 (K), R174.1; also elsewhere on the board
unnamed: D39.1 (K), D40.2 (A)

Notes on the sheet:
METER L: full-wave rectifier, precision peak / average, follower (TL072), 2 dB ladder, 2 x 10-LED strings (cont.)

Schematic: 22_meter_l.kicad_sch, METER L

Parts:
D41: green +0 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
D42: amber +2 dB; LED_D3.0mm; MPN Kingbright WP710A10ND
D43: amber +4 dB; LED_D3.0mm; MPN Kingbright WP710A10ND
D44: amber +6 dB; LED_D3.0mm; MPN Kingbright WP710A10ND
D45: amber +8 dB; LED_D3.0mm; MPN Kingbright WP710A10ND
D46: amber +10 dB; LED_D3.0mm; MPN Kingbright WP710A10ND
D47: red +12 dB; LED_D3.0mm; MPN Kingbright WP710A10ID
D48: red +14 dB; LED_D3.0mm; MPN Kingbright WP710A10ID
D49: red +16 dB; LED_D3.0mm; MPN Kingbright WP710A10ID
D50: red +18 dB; LED_D3.0mm; MPN Kingbright WP710A10ID
Q3: BCP53-16; SOT-223; MPN onsemi BCP53-16T1G
U33, U34, U35: LM2901; SOIC-14_3.9x8.7mm_P1.27mm; MPN TI LM2901BIDR

Connections:
-VM: D50.1 (K); also elsewhere on the board
MLB_5: D45.1 (K), D46.2 (A), U34.14
MLB_QB: Q3.1 (B); also elsewhere on the board
MLB_QE: Q3.3 (E); also elsewhere on the board
ML_DET: U33.9 (+), U33.11 (+), U34.5 (+), U34.7 (+), U34.9 (+), U34.11 (+), U35.5 (+), U35.7 (+), U35.9 (+), U35.11 (+); also elsewhere on the board
ML_T11: U33.10 (-); also elsewhere on the board
ML_T12: U33.8 (-); also elsewhere on the board
ML_T13: U34.4 (-); also elsewhere on the board
ML_T14: U34.6 (-); also elsewhere on the board
ML_T15: U34.10 (-); also elsewhere on the board
ML_T16: U34.8 (-); also elsewhere on the board
ML_T17: U35.4 (-); also elsewhere on the board
ML_T18: U35.6 (-); also elsewhere on the board
ML_T19: U35.10 (-); also elsewhere on the board
ML_T20: U35.8 (-); also elsewhere on the board
unnamed: D41.2 (A), Q3.2 (C), Q3.4 (C), U33.13
unnamed: D41.1 (K), D42.2 (A), U33.14
unnamed: D42.1 (K), D43.2 (A), U34.2
unnamed: D43.1 (K), D44.2 (A), U34.1
unnamed: D44.1 (K), D45.2 (A), U34.13
unnamed: D46.1 (K), D47.2 (A), U35.2
unnamed: D47.1 (K), D48.2 (A), U35.1
unnamed: D48.1 (K), D49.2 (A), U35.13
unnamed: D49.1 (K), D50.2 (A), U35.14

Notes on the sheet:
METER L: full-wave rectifier, precision peak / average, follower (TL072), 2 dB ladder, 2 x 10-LED strings (cont.)

Schematic: 23_meter_r.kicad_sch, METER R

Parts:
C172, C173, C176, C177, C180, C181: 100n; C_0805_2012Metric; MPN Samsung CL21B104KBCNNNC (X7R 50V)
C175: 2.2u film; C_Rect_L7.2mm_W7.2mm_P5.00mm_FKS2_FKP2_MKS2_MKP2; MPN KEMET MMK5225K63J06L4BULK (PET 63V; rep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
C178: 1u; C_1206_3216Metric; MPN Samsung CL31B105KBHNNNE (X7R 50V)
C179: 22p C0G; C_0805_2012Metric; MPN KEMET C0805C220J5GACTU
D53, D54, D55, D56, D67, D68: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal; MPN Vishay 1N4148-TAP
JP2: PEAK(1-2) / AVG; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
R181: 33K; R_0805_2012Metric
R182: 220R; R_0805_2012Metric
R183: 330K; R_0805_2012Metric
R184: 220K; R_0805_2012Metric
R185: 10K; R_0805_2012Metric
R186: 470R; R_0805_2012Metric
R197: 180R; R_0805_2012Metric
R198: 150R; R_0805_2012Metric
R199: 110R; R_0805_2012Metric
R200, R207: 91R; R_0805_2012Metric
R201: 68R; R_0805_2012Metric
R202: 62R; R_0805_2012Metric
R203: 47R; R_0805_2012Metric
R204: 33R; R_0805_2012Metric
R205: 27R; R_0805_2012Metric
R206: 20R; R_0805_2012Metric
R209, R211: 27K; R_0805_2012Metric
U19: OPA1612; SOIC-8_3.9x4.9mm_P1.27mm; MPN TI OPA1612AIDR
U36, U37: TL072; SOIC-8_3.9x4.9mm_P1.27mm; MPN TI TL072HIDR
U38: LM2901; SOIC-14_3.9x8.7mm_P1.27mm; MPN TI LM2901BIDR

Connections:
+VM: C172.1, C176.1, C180.1, D55.2 (A), D67.2 (A), U36.8 (V+), U37.8 (V+), U38.3 (V+); also elsewhere on the board
-VM: C173.2, C177.2, C181.2, R209.2, R211.2, U36.4 (V-), U37.4 (V-), U38.12 (V-); also elsewhere on the board
GNDM: C172.2, C173.1, C175.2, C176.2, C177.1, C178.2, C180.2, C181.1, R184.2, R207.2, U36.3 (+), U36.5 (+); also elsewhere on the board
MRA_QB: D56.1 (K), R209.1; also elsewhere on the board
MRB_QB: D68.1 (K), R211.1; also elsewhere on the board
MR_DET: R186.2; also elsewhere on the board
MR_DETO: R185.1, R186.1, U37.6 (-), U37.7
MR_T1: R206.2, R207.1; also elsewhere on the board
MR_T2: R205.2, R206.1; also elsewhere on the board
MR_T3: R204.2, R205.1; also elsewhere on the board
MR_T4: R203.2, R204.1; also elsewhere on the board
MR_T5: R202.2, R203.1; also elsewhere on the board
MR_T6: R201.2, R202.1; also elsewhere on the board
MR_T7: R200.2, R201.1; also elsewhere on the board
MR_T8: R199.2, R200.1; also elsewhere on the board
MR_T9: R198.2, R199.1; also elsewhere on the board
MR_T10: R197.2, R198.1; also elsewhere on the board
MR_T11: R197.1; also elsewhere on the board
MR_X2: R181.1, U36.7, U37.3 (+); also elsewhere on the board
unnamed: C178.1, R182.2, R183.1
unnamed 232: U36.1; also elsewhere on the board
unnamed 233: U36.2 (-); also elsewhere on the board
unnamed: C179.1, D53.2 (A), D54.1 (K), U37.1
unnamed: D53.1 (K), JP2.1 (A), R182.1
unnamed: C179.2, D54.2 (A), R185.2, U37.2 (-)
unnamed: D55.1 (K), D56.2 (A)
unnamed: D67.1 (K), D68.2 (A)
unnamed: C175.1, JP2.3 (B), R181.2
unnamed: JP2.2 (C), U37.5 (+)
unnamed: R183.2, R184.1
unnamed: U19.6 (-), U19.7
unnamed 329: U36.6 (-); also elsewhere on the board

Notes on the sheet:
METER R: full-wave rectifier, precision peak / average, follower (TL072), 2 dB ladder, 2 x 10-LED strings (cont.)

Schematic: 24_meter_r.kicad_sch, METER R

Parts:
C172, C173, C176, C177, C180, C181, C182, C183, C184, C185, C186, C187, C188, C189: 100n; C_0805_2012Metric; MPN Samsung CL21B104KBCNNNC (X7R 50V)
D55, D56, D67, D68: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal; MPN Vishay 1N4148-TAP
R197: 180R; R_0805_2012Metric
R198: 150R; R_0805_2012Metric
R199: 110R; R_0805_2012Metric
R200, R207: 91R; R_0805_2012Metric
R201: 68R; R_0805_2012Metric
R202: 62R; R_0805_2012Metric
R203: 47R; R_0805_2012Metric
R204: 33R; R_0805_2012Metric
R205: 27R; R_0805_2012Metric
R206: 20R; R_0805_2012Metric
R209, R211: 27K; R_0805_2012Metric
U19: OPA1612; SOIC-8_3.9x4.9mm_P1.27mm; MPN TI OPA1612AIDR
U36, U37: TL072; SOIC-8_3.9x4.9mm_P1.27mm; MPN TI TL072HIDR
U38, U39, U40, U41, U42: LM2901; SOIC-14_3.9x8.7mm_P1.27mm; MPN TI LM2901BIDR

Connections:
+VM: C172.1, C176.1, C180.1, C182.1, C184.1, C186.1, C188.1, D55.2 (A), D67.2 (A), U36.8 (V+), U37.8 (V+), U38.3 (V+), U39.3 (V+), U40.3 (V+), U41.3 (V+), U42.3 (V+); also elsewhere on the board
-VM: C173.2, C177.2, C181.2, C183.2, C185.2, C187.2, C189.2, R209.2, R211.2, U36.4 (V-), U37.4 (V-), U38.12 (V-), U39.12 (V-), U40.12 (V-), U41.12 (V-), U42.12 (V-); also elsewhere on the board
GNDM: C172.2, C173.1, C176.2, C177.1, C180.2, C181.1, C182.2, C183.1, C184.2, C185.1, C186.2, C187.1, C188.2, C189.1, R207.2, U36.3 (+), U36.5 (+); also elsewhere on the board
MRA_QB: D56.1 (K), R209.1; also elsewhere on the board
MRB_QB: D68.1 (K), R211.1; also elsewhere on the board
MR_T1: R206.2, R207.1; also elsewhere on the board
MR_T2: R205.2, R206.1; also elsewhere on the board
MR_T3: R204.2, R205.1; also elsewhere on the board
MR_T4: R203.2, R204.1; also elsewhere on the board
MR_T5: R202.2, R203.1; also elsewhere on the board
MR_T6: R201.2, R202.1; also elsewhere on the board
MR_T7: R200.2, R201.1; also elsewhere on the board
MR_T8: R199.2, R200.1; also elsewhere on the board
MR_T9: R198.2, R199.1; also elsewhere on the board
MR_T10: R197.2, R198.1; also elsewhere on the board
MR_T11: R197.1; also elsewhere on the board
MR_X2: U36.7; also elsewhere on the board
unnamed 232: U36.1; also elsewhere on the board
unnamed 233: U36.2 (-); also elsewhere on the board
unnamed: D55.1 (K), D56.2 (A)
unnamed: D67.1 (K), D68.2 (A)
unnamed: U19.6 (-), U19.7
unnamed 329: U36.6 (-); also elsewhere on the board

Notes on the sheet:
METER R: full-wave rectifier, precision peak / average, follower (TL072), 2 dB ladder, 2 x 10-LED strings (cont.)

Schematic: 25_meter_r.kicad_sch, METER R

Parts:
D57: green -20 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
D58: green -18 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
D59: green -16 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
D60: green -14 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
D61: green -12 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
D62: green -10 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
D63: green -8 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
D64: green -6 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
D65: green -4 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
D66: green -2 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
Q4: BCP53-16; SOT-223; MPN onsemi BCP53-16T1G
U38, U39, U40: LM2901; SOIC-14_3.9x8.7mm_P1.27mm; MPN TI LM2901BIDR

Connections:
-VM: D66.1 (K); also elsewhere on the board
MRA_5: D61.1 (K), D62.2 (A), U39.1
MRA_QB: Q4.1 (B); also elsewhere on the board
MRA_QE: Q4.3 (E); also elsewhere on the board
MR_DET: U38.5 (+), U38.7 (+), U38.9 (+), U38.11 (+), U39.5 (+), U39.7 (+), U39.9 (+), U39.11 (+), U40.5 (+), U40.7 (+); also elsewhere on the board
MR_T1: U38.4 (-); also elsewhere on the board
MR_T2: U38.6 (-); also elsewhere on the board
MR_T3: U38.10 (-); also elsewhere on the board
MR_T4: U38.8 (-); also elsewhere on the board
MR_T5: U39.4 (-); also elsewhere on the board
MR_T6: U39.6 (-); also elsewhere on the board
MR_T7: U39.10 (-); also elsewhere on the board
MR_T8: U39.8 (-); also elsewhere on the board
MR_T9: U40.4 (-); also elsewhere on the board
MR_T10: U40.6 (-); also elsewhere on the board
unnamed: D57.2 (A), Q4.2 (C), Q4.4 (C), U38.2
unnamed: D57.1 (K), D58.2 (A), U38.1
unnamed: D58.1 (K), D59.2 (A), U38.13
unnamed: D59.1 (K), D60.2 (A), U38.14
unnamed: D60.1 (K), D61.2 (A), U39.2
unnamed: D62.1 (K), D63.2 (A), U39.13
unnamed: D63.1 (K), D64.2 (A), U39.14
unnamed: D64.1 (K), D65.2 (A), U40.2
unnamed: D65.1 (K), D66.2 (A), U40.1

Notes on the sheet:
METER R: full-wave rectifier, precision peak / average, follower (TL072), 2 dB ladder, 2 x 10-LED strings (cont.)

Schematic: 26_meter_r.kicad_sch, METER R

Parts:
D69: green +0 dB; LED_D3.0mm; MPN Kingbright WP710A10GD
D70: amber +2 dB; LED_D3.0mm; MPN Kingbright WP710A10ND
D71: amber +4 dB; LED_D3.0mm; MPN Kingbright WP710A10ND
D72: amber +6 dB; LED_D3.0mm; MPN Kingbright WP710A10ND
D73: amber +8 dB; LED_D3.0mm; MPN Kingbright WP710A10ND
D74: amber +10 dB; LED_D3.0mm; MPN Kingbright WP710A10ND
D75: red +12 dB; LED_D3.0mm; MPN Kingbright WP710A10ID
D76: red +14 dB; LED_D3.0mm; MPN Kingbright WP710A10ID
D77: red +16 dB; LED_D3.0mm; MPN Kingbright WP710A10ID
D78: red +18 dB; LED_D3.0mm; MPN Kingbright WP710A10ID
Q5: BCP53-16; SOT-223; MPN onsemi BCP53-16T1G
U40, U41, U42: LM2901; SOIC-14_3.9x8.7mm_P1.27mm; MPN TI LM2901BIDR

Connections:
-VM: D78.1 (K); also elsewhere on the board
MRB_5: D73.1 (K), D74.2 (A), U41.14
MRB_QB: Q5.1 (B); also elsewhere on the board
MRB_QE: Q5.3 (E); also elsewhere on the board
MR_DET: U40.9 (+), U40.11 (+), U41.5 (+), U41.7 (+), U41.9 (+), U41.11 (+), U42.5 (+), U42.7 (+), U42.9 (+), U42.11 (+); also elsewhere on the board
MR_T11: U40.10 (-); also elsewhere on the board
MR_T12: U40.8 (-); also elsewhere on the board
MR_T13: U41.4 (-); also elsewhere on the board
MR_T14: U41.6 (-); also elsewhere on the board
MR_T15: U41.10 (-); also elsewhere on the board
MR_T16: U41.8 (-); also elsewhere on the board
MR_T17: U42.4 (-); also elsewhere on the board
MR_T18: U42.6 (-); also elsewhere on the board
MR_T19: U42.10 (-); also elsewhere on the board
MR_T20: U42.8 (-); also elsewhere on the board
unnamed: D69.2 (A), Q5.2 (C), Q5.4 (C), U40.13
unnamed: D69.1 (K), D70.2 (A), U40.14
unnamed: D70.1 (K), D71.2 (A), U41.2
unnamed: D71.1 (K), D72.2 (A), U41.1
unnamed: D72.1 (K), D73.2 (A), U41.13
unnamed: D74.1 (K), D75.2 (A), U42.2
unnamed: D75.1 (K), D76.2 (A), U42.1
unnamed: D76.1 (K), D77.2 (A), U42.13
unnamed: D77.1 (K), D78.2 (A), U42.14

Notes on the sheet:
METER R: full-wave rectifier, precision peak / average, follower (TL072), 2 dB ladder, 2 x 10-LED strings (cont.)

Schematic: 27_jack_link_clamps.kicad_sch, JACK LINK CLAMPS

Parts:
D79, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D92, D93, D94, D95, D96, D97, D98, D99: BAV199; SOT-23; MPN Nexperia BAV199,215

Connections:
+VA: D79.2 (A), D80.2 (A), D81.2 (A), D82.2 (A), D83.2 (A), D84.2 (A), D85.2 (A), D86.2 (A), D87.2 (A), D88.2 (A), D89.2 (A), D90.2 (A), D91.2 (A), D92.2 (A), D93.2 (A), D94.2 (A), D95.2 (A), D96.2 (A), D97.2 (A), D98.2 (A), D99.2 (A); also elsewhere on the board
-VA: D79.1 (K), D80.1 (K), D81.1 (K), D82.1 (K), D83.1 (K), D84.1 (K), D85.1 (K), D86.1 (K), D87.1 (K), D88.1 (K), D89.1 (K), D90.1 (K), D91.1 (K), D92.1 (K), D93.1 (K), D94.1 (K), D95.1 (K), D96.1 (K), D97.1 (K), D98.1 (K), D99.1 (K); also elsewhere on the board
A5_ON: D90.3 (K); also elsewhere on the board
A5_OP: D89.3 (K); also elsewhere on the board
A6_ON: D92.3 (K); also elsewhere on the board
A6_OP: D91.3 (K); also elsewhere on the board
CRL_XN: D98.3 (K); also elsewhere on the board
CRL_XP: D97.3 (K); also elsewhere on the board
CRR_XP: D99.3 (K); also elsewhere on the board
EXT_LR: D94.3 (K); also elsewhere on the board
EXT_LT: D93.3 (K); also elsewhere on the board
EXT_RR: D96.3 (K); also elsewhere on the board
EXT_RT: D95.3 (K); also elsewhere on the board
MAIN_L_XN: D84.3 (K); also elsewhere on the board
MAIN_L_XP: D83.3 (K); also elsewhere on the board
MAIN_M_XN: D88.3 (K); also elsewhere on the board
MAIN_M_XP: D87.3 (K); also elsewhere on the board
MAIN_R_XN: D86.3 (K); also elsewhere on the board
MAIN_R_XP: D85.3 (K); also elsewhere on the board
MIX_L_RETRAW: D80.3 (K); also elsewhere on the board
MIX_L_SEND: D79.3 (K); also elsewhere on the board
MIX_R_RETRAW: D82.3 (K); also elsewhere on the board
MIX_R_SEND: D81.3 (K); also elsewhere on the board

Notes on the sheet:
JACK LINK CLAMPS: a BAV199 to the audio rails on every jack signal at the link (CS4b)

Schematic: 28_jack_link_clamps.kicad_sch, JACK LINK CLAMPS, SPARE BUS GROUNDING

Parts:
D100, D101, D102: BAV199; SOT-23; MPN Nexperia BAV199,215
JP3: SPARE1 to GNDA; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP4: SPARE3 to GNDA; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP5: SPARE5 to GNDA; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP6: SPARE7 to GNDA; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP7: SPARE19 to GNDA; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm

Connections:
+VA: D100.2 (A), D101.2 (A), D102.2 (A); also elsewhere on the board
-VA: D100.1 (K), D101.1 (K), D102.1 (K); also elsewhere on the board
CRR_XN: D100.3 (K); also elsewhere on the board
PHJ_L: D101.3 (K); also elsewhere on the board
PHJ_R: D102.3 (K); also elsewhere on the board
SPARE1: JP3.1 (A); also elsewhere on the board
SPARE3: JP4.1 (A); also elsewhere on the board
SPARE5: JP5.1 (A); also elsewhere on the board
SPARE7: JP6.1 (A); also elsewhere on the board
SPARE19: JP7.1 (A); also elsewhere on the board

Notes on the sheet:
JACK LINK CLAMPS: a BAV199 to the audio rails on every jack signal at the link (CS4b) (cont.)
SPARE BUS GROUNDING bridged solder jumpers from each spare conductor to GNDA (D13; open for SUB 5-8)

Schematic: 29_power_entry.kicad_sch, POWER ENTRY, DISTRIBUTION

Parts:
C1, C2: 470u 25V; CP_Radial_D10.0mm_P5.00mm; MPN Nichicon UPW1E471MPD
C3, C4: 1000u 25V; CP_Radial_D12.5mm_P5.00mm; MPN Nichicon UPW1E102MHD
C5: 47u 25V; CP_Radial_D8.0mm_P3.50mm; MPN Nichicon UPW1J470MPD (63V)
CN1: Ground bar M4 (star point); MountingHole_4.3mm_M4_Pad
D1, D2: SS54; D_SMC; MPN Diodes B540C-13-F (SS54 class, SMC 40 V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
F1, F3: MF-RX250/72; Fuse_Bourns_MF-RX250-72_Radial_P10.16mm; MPN Bourns MF-RX250/72-0
F2, F4: MF-RX185/72; Fuse_Bourns_MF-RX185-72_Radial_P5.08mm; MPN Bourns MF-RX185/72-0
J1: PSU in (NC7MD-LX); TerminalBlock_Phoenix_MKDS-1,5-7-5.08_1x07_P5.08mm_Horizont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; MPN Phoenix 1755897 MKDS 1,5/7-5,08 (wired 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
NT1: Star GNDA-GNDD; NetTie-2_SMD_Pad0.5mm
NT2: Star GNDA-GNDM; NetTie-2_SMD_Pad0.5mm
NT3: Star GNDA-PHONESGND; NetTie-2_SMD_Pad0.5mm
NT4: Star GNDA-CHASSIS; NetTie-2_SMD_Pad0.5mm
R1, R2: 1R; R_0805_2012Metric; MPN Panasonic ERJ-P06J1R0V
R3, R4: 2R2; R_2512_6332Metric; MPN Vishay CRCW25122R20FKEGHP
R5: 10R; R_0805_2012Metric

Connections:
+VA: C1.1, R1.2; also elsewhere on the board
+VBUS: D1.1 (K), F1.1, F3.1, J1.2, J1.3, R1.1, R3.1, R5.1; also elsewhere on the board
+VBUS_L: F1.2; also elsewhere on the board
+VBUS_R: F3.2; also elsewhere on the board
+VM: C5.1, R5.2; also elsewhere on the board
+VP: C3.1, R3.2; also elsewhere on the board
-VA: C2.2, R2.2; also elsewhere on the board
-VBUS: D2.2 (A), F2.1, F4.1, J1.6, J1.7, R2.1, R4.1; also elsewhere on the board
-VBUS_L: F2.2; also elsewhere on the board
-VBUS_R: F4.2; also elsewhere on the board
-VP: C4.2, R4.2; also elsewhere on the board
CHASSIS: J1.1, NT4.2; also elsewhere on the board
GNDD: NT1.2; also elsewhere on the board
GNDM: C5.2, NT2.2; also elsewhere on the board
PHONESGND: NT3.2; also elsewhere on the board

Notes on the sheet:
POWER ENTRY (7-pin XLR NC7MD-LX on the rear panel, two 5 A contacts per rail, 18 AWG to this terminal; +-17 V PSU)
DISTRIBUTION (PTC per wing per rail, 1.85 A hold, 72 V; local branches VA audio, VP phones, VM meters, VL logic)

Schematic: 30_distribution.kicad_sch, DISTRIBUTION, MOTHERLOOM

Parts:
C6, C7, C8: 47u 25V; CP_Radial_D8.0mm_P3.50mm; MPN Nichicon UPW1J470MPD (63V)
CN2: Bus L wing 2x17; IDC-Header_2x17_P2.54mm_Vertical; MPN Wurth 61203421621 (2x17 box header)
CN3: Bus R wing 2x17; IDC-Header_2x17_P2.54mm_Vertical; MPN Wurth 61203421621 (2x17 box header)
D3: Power green; LED_D3.0mm; MPN Kingbright WP710A10GD
R6, R7, R8: 10R; R_0805_2012Metric
R9: 4K7; R_0805_2012Metric

Connections:
+VBUS: R7.1; also elsewhere on the board
+VBUS_L: CN2.32, CN2.33, CN2.34; also elsewhere on the board
+VBUS_R: CN3.32, CN3.33, CN3.34; also elsewhere on the board
+VL: C7.1, R7.2, R9.1; also elsewhere on the board
-VBUS: R6.1, R8.1; also elsewhere on the board
-VBUS_L: CN2.30, CN2.31; also elsewhere on the board
-VBUS_R: CN3.30, CN3.31; also elsewhere on the board
-VL: C8.2, R8.2; also elsewhere on the board
-VM: C6.2, R6.2; also elsewhere on the board
AUX1: CN2.24, CN3.24
AUX2: CN2.25, CN3.25
AUX3: CN2.23, CN3.23
AUX4: CN2.22, CN3.22
AUX5: CN2.21, CN3.21; also elsewhere on the board
AUX6: CN2.20, CN3.20; also elsewhere on the board
GCANCEL: CN2.26, CN3.26; also elsewhere on the board
GNDD: C7.2, C8.1, D3.1 (K); also elsewhere on the board
GNDM: C6.1; also elsewhere on the board
MIXL: CN2.18, CN3.18; also elsewhere on the board
MIXR: CN2.17, CN3.17; also elsewhere on the board
unnamed: D3.2 (A), R9.2
PFL: CN2.27, CN3.27; also elsewhere on the board
PFLDET: CN2.29, CN3.29; also elsewhere on the board
PFLN: CN2.28, CN3.28
SPARE1: CN2.1, CN3.1; also elsewhere on the board
SPARE3: CN2.3, CN3.3; also elsewhere on the board
SPARE5: CN2.5, CN3.5; also elsewhere on the board
SPARE7: CN2.7, CN3.7; also elsewhere on the board
SPARE19: CN2.19, CN3.19; also elsewhere on the board
SUB1: CN2.15, CN3.15
SUB2: CN2.13, CN3.13
SUB3: CN2.11, CN3.11
SUB4: CN2.9, CN3.9

Notes on the sheet:
DISTRIBUTION (cont.)
MOTHERLOOM (master in the centre: CN1 = left wing, CN2 = right wing; Delta pinout)

Schematic: 31_remote_meter_header.kicad_sch, REMOTE METER HEADER, JACK BOARD LINK

Parts:
CN4: Remote meter; PinHeader_1x05_P2.54mm_Vertical; MPN Sullins PRPC005SAAN-RC
CN5: Jack board link 2x20; IDC-Header_2x20_P2.54mm_Vertical; MPN Wurth 61204021621 (2x20 box header)

Connections:
+VM: CN4.3; also elsewhere on the board
-VM: CN4.5; also elsewhere on the board
A5_ON: CN5.20; also elsewhere on the board
A5_OP: CN5.19; also elsewhere on the board
A6_ON: CN5.23; also elsewhere on the board
A6_OP: CN5.22; also elsewhere on the board
CHASSIS: CN5.9; also elsewhere on the board
CRL_XN: CN5.32; also elsewhere on the board
CRL_XP: CN5.31; also elsewhere on the board
CRR_XN: CN5.35; also elsewhere on the board
CRR_XP: CN5.34; also elsewhere on the board
EXT_LR: CN5.26; also elsewhere on the board
EXT_LT: CN5.25; also elsewhere on the board
EXT_RR: CN5.29; also elsewhere on the board
EXT_RT: CN5.28; also elsewhere on the board
GNDM: CN4.4; also elsewhere on the board
MAIN_L_XN: CN5.11; also elsewhere on the board
MAIN_L_XP: CN5.10; also elsewhere on the board
MAIN_M_XN: CN5.17; also elsewhere on the board
MAIN_M_XP: CN5.16; also elsewhere on the board
MAIN_R_XN: CN5.14; also elsewhere on the board
MAIN_R_XP: CN5.13; also elsewhere on the board
MIX_L_RETRAW: CN5.3; also elsewhere on the board
MIX_L_SEND: CN5.1; also elsewhere on the board
MIX_R_RETRAW: CN5.7; also elsewhere on the board
MIX_R_SEND: CN5.5; also elsewhere on the board
MTR_L: CN4.1; also elsewhere on the board
MTR_R: CN4.2; also elsewhere on the board
PHJ_L: CN5.37; also elsewhere on the board
PHJ_R: CN5.38; also elsewhere on the board
PHONESGND: CN5.39; also elsewhere on the board

Notes on the sheet:
REMOTE METER HEADER (for a meter bridge)
JACK BOARD LINK 2x20 IDC ribbon to the master jack board (9 jacks, 3 XLRs)

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
Board: 4 copper layers, 639 parts (122 on the bottom side), 387 nets, no tracks yet.

Other parts of the board:
C174: 22p C0G; C_0805_2012Metric
C194, C195: 2.2u film; C_Rect_L7.2mm_W7.2mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C196, C197: 33u NP 25V; CP_Radial_D8.0mm_P3.50mm
D51, D52: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
H1, H2, H3, H4, H5, H6, H7: M3 standoff 11.5 mm; MountingHole_3.2mm_M3
R175: 100R; R_0805_2012Metric
R176, R177, R179, R180: 10K; R_0805_2012Metric
R178: 20K; R_0805_2012Metric
R187: 16K; R_0805_2012Metric
R188: 1K5; R_0805_2012Metric
R189: 1K1; R_0805_2012Metric
R190: 910R; R_0805_2012Metric
R191: 680R; R_0805_2012Metric
R192: 620R; R_0805_2012Metric
R193: 470R; R_0805_2012Metric
R194: 330R; R_0805_2012Metric
R195: 300R; R_0805_2012Metric
R196: 220R; R_0805_2012Metric
R208, R210: 120R; R_0805_2012Metric
RV8: Cal 10K; Potentiometer_Bourns_3296W_Vertical

Their connections:
+VM: R187.1, R208.1, R210.1; also elsewhere on the board
A5_AFLC: C194.2; also elsewhere on the board
A5_OUT: C194.1; also elsewhere on the board
CRSB_R: R175.1; also elsewhere on the board
MRA_QE: R208.2; also elsewhere on the board
MRB_QE: R210.2; also elsewhere on the board
MR_HW: D51.2, R177.2, R179.1
MR_T11: R196.2; also elsewhere on the board
MR_T12: R195.2, R196.1; also elsewhere on the board
MR_T13: R194.2, R195.1; also elsewhere on the board
MR_T14: R193.2, R194.1; also elsewhere on the board
MR_T15: R192.2, R193.1; also elsewhere on the board
MR_T16: R191.2, R192.1; also elsewhere on the board
MR_T17: R190.2, R191.1; also elsewhere on the board
MR_T18: R189.2, R190.1; also elsewhere on the board
MR_T19: R188.2, R189.1; also elsewhere on the board
MR_T20: R187.2, R188.1; also elsewhere on the board
MR_X2: C174.1, R180.1; also elsewhere on the board
MTR_R: R175.2, R176.1, R178.1; also elsewhere on the board
unnamed 232: D51.1, D52.2; also elsewhere on the board
unnamed 233: D52.1, R176.2, R177.1; also elsewhere on the board
unnamed: R180.2, RV8.1
unnamed 329: C174.2, R178.2, R179.2, RV8.2, RV8.3; also elsewhere on the board
PH_GL: C196.1; also elsewhere on the board

File master_BOM.csv (part):

"Qty","Value","Footprint","MPN","DNP","References"
"2","470u 25V","Capacitor_THT:CP_Radial_D10.0mm_P5.00mm","Nichicon UPW1E471MPD","","C1 C2"
"2","1000u 25V","Capacitor_THT:CP_Radial_D12.5mm_P5.00mm","Nichicon UPW1E102MHD","","C3 C4"
"4","47u 25V","Capacitor_THT:CP_Radial_D8.0mm_P3.50mm","Nichicon UPW1J470MPD (63V)","","C5 C6 C7 C8"
"75","100n","Capacitor_SMD:C_0805_2012Metric","Samsung CL21B104KBCNNNC (X7R 50V)","","C9 C10 C14 C15 C19 C20 C26 C27 C30 C31 C41 C42 C55 C56 C58 C59 C60 C61 C67 C68 C75 C76 C92 C93 C100 C101 C107 C108 C115 C116 C117 C118 C119 C121 C122 C125 C126 C139 C140 C142 C143 C149 C150 C154 C155 C158 C159 C162 C163 C164 C165 C166 C167 C168 C169 C170 C171 C172 C173 C176 C177 C180 C181 C182 C183 C184 C185 C186 C187 C188 C189 C190 C191 C192 C193"
"18","100p C0G","Capacitor_SMD:C_0805_2012Metric","KEMET C0805C101J5GACTU","","C11 C17 C21 C25 C33 C37 C39 C62 C69 C77 C82 C88 C89 C94 C95 C102 C146 C153"
"10","22p C0G 5%","Capacitor_SMD:C_0805_2012Metric","KEMET C0805C220J5GACTU","","C12 C13 C22 C23 C63 C64 C78 C79 C103 C104"
"13","33u NP 25V","Capacitor_THT:CP_Radial_D8.0mm_P3.50mm","Nichicon UES1E330MPM (MUSE ES)","","C16 C24 C65 C80 C98 C99 C105 C111 C112 C113 C114 C196 C197"
"4","100u NP 25V","Capacitor_THT:CP_Radial_D10.0mm_P5.00mm","Nichicon UES1E101MPM (MUSE ES)","","C18 C28 C34 C38"
"13","2.2u film","Capacitor_THT:C_Rect_L7.2mm_W7.2mm_P5.00mm_FKS2_FKP2_MKS2_MKP2","KEMET MMK5225K63J06L4BULK (PET 63V; replaces the obsolete WIMA MKS2C042201K00KSSD)","","C29 C35 C66 C81 C106 C124 C128 C138 C147 C157 C175 C194 C195"
"4","10p C0G","Capacitor_SMD:C_0805_2012Metric","KEMET C0805C100J5GACTU","","C32 C36 C70 C83"
"10","22p C0G","Capacitor_SMD:C_0805_2012Metric","KEMET C0805C220J5GACTU","","C40 C109 C127 C129 C141 C148 C156 C161 C174 C179"
"14","10u NP 25V","Capacitor_THT:CP_Radial_D5.0mm_P2.00mm","Panasonic ECE-A1EN100U (matched pair: the two at one DRV135 within 2 %, sorted at 100 Hz)","","C43 C44 C47 C48 C51 C52 C71 C72 C84 C85 C130 C131 C134 C135"
"18","1u","Capacitor_SMD:C_1206_3216Metric","Samsung CL31B105KBHNNNE (X7R 50V)","","C45 C46 C49 C50 C53 C54 C73 C74 C86 C87 C110 C120 C132 C133 C136 C137 C160 C178"
"1","2.2u film 63V","Capacitor_THT:C_Rect_L7.2mm_W7.2mm_P5.00mm_FKS2_FKP2_MKS2_MKP2","KEMET MMK5225K63J06L4BULK (PET 63V; replaces the obsolete WIMA MKS2C042201K00KSSD)","","C57"
"4","33p C0G","Capacitor_SMD:C_0805_2012Metric","KEMET C0805C330J5GACTU","","C90 C91 C96 C97"
"1","330n","Capacitor_SMD:C_0805_2012Metric","Samsung CL21B334KBFNNNE (X7R 50V)","","C123"
"4","10u NP 25V","Capacitor_THT:CP_Radial_D5.0mm_P2.00mm","Panasonic ECE-A1EN100U","","C144 C145 C151 C152"
"1","Ground bar M4 (star point)","MountingHole:MountingHole_4.3mm_M4_Pad","","","CN1"
"1","Bus L wing 2x17","Connector_IDC:IDC-Header_2x17_P2.54mm_Vertical","Wurth 61203421621 (2x17 box header)","","CN2"
"1","Bus R wing 2x17","Connector_IDC:IDC-Header_2x17_P2.54mm_Vertical","Wurth 61203421621 (2x17 box header)","","CN3"
"1","Remote meter","Connector_PinHeader_2.54mm:PinHeader_1x05_P2.54mm_Vertical","Sullins PRPC005SAAN-RC","","CN4"
"1","Jack board link 2x20","Connector_IDC:IDC-Header_2x20_P2.54mm_Vertical","Wurth 61204021621 (2x20 box header)","","CN5"
"2","SS54","Diode_SMD:D_SMC","Diodes B540C-13-F (SS54 class, SMC 40 V 5 A)","","D1 D2"
"1","Power green","LED_THT:LED_D3.0mm","Kingbright WP710A10GD","","D3"
"29","1N4148","Diode_THT:D_DO-35_SOD27_P7.62mm_Horizontal","Vishay 1N4148-TAP","","D4 D5 D6 D8 D9 D10 D11 D16 D17 D18 D20 D21 D22 D23 D24 D25 D26 D27 D28 D39 D40 D51 D52 D53 D54 D55 D56 D67 D68"
"1","BZT52C6V2","Diode_SMD:D_SOD-123","Diodes BZT52C6V2-7-F","","D7"
"1","Aux 5 AFL red","LED_THT:LED_D3.0mm","Kingbright WP710A10ID","","D12"
"1","Aux 6 AFL red","LED_THT:LED_D3.0mm","Kingbright WP710A10ID","","D13"
"1","BZX84C5V1","Package_TO_SOT_SMD:SOT-23","Nexperia BZX84-C5V1,215","","D14"
"1","BAT54W","Package_TO_SOT_SMD:SOT-323_SC-70","Nexperia BAT54W,115","","D15"
"1","PFL ACTIVE red 5mm","LED_THT:LED_D5.0mm","Kingbright WP7113ID","","D19"
"2","green -20 dB","LED_THT:LED_D3.0mm","Kingbright WP710A10GD","","D29 D57"
"2","green -18 dB","LED_THT:LED_D3.0mm","Kingbright WP710A10GD","","D30 D58"
"2","green -16 dB","LED_THT:LED_D3.0mm","Kingbright WP710A10GD","","D31 D59"
"2","green -14 dB","LED_THT:LED_D3.0mm","Kingbright WP710A10GD","","D32 D60"
"2","green -12 dB","LED_THT:LED_D3.0mm","Kingbright WP710A10GD","","D33 D61"
"2","green -10 dB","LED_THT:LED_D3.0mm","Kingbright WP710A10GD","","D34 D62"
"2","green -8 dB","LED_THT:LED_D3.0mm","Kingbright WP710A10GD","","D35 D63"
"2","green -6 dB","LED_THT:LED_D3.0mm","Kingbright WP710A10GD","","D36 D64"
"2","green -4 dB","LED_THT:LED_D3.0mm","Kingbright WP710A10GD","","D37 D65"
"2","green -2 dB","LED_THT:LED_D3.0mm","Kingbright WP710A10GD","","D38 D66"
"2","green +0 dB","LED_THT:LED_D3.0mm","Kingbright WP710A10GD","","D41 D69"
"2","amber +2 dB","LED_THT:LED_D3.0mm","Kingbright WP710A10ND","","D42 D70"
"2","amber +4 dB","LED_THT:LED_D3.0mm","Kingbright WP710A10ND","","D43 D71"
"2","amber +6 dB","LED_THT:LED_D3.0mm","Kingbright WP710A10ND","","D44 D72"
"2","amber +8 dB","LED_THT:LED_D3.0mm","Kingbright WP710A10ND","","D45 D73"
"2","amber +10 dB","LED_THT:LED_D3.0mm","Kingbright WP710A10ND","","D46 D74"
"2","red +12 dB","LED_THT:LED_D3.0mm","Kingbright WP710A10ID","","D47 D75"
"2","red +14 dB","LED_THT:LED_D3.0mm","Kingbright WP710A10ID","","D48 D76"
"2","red +16 dB","LED_THT:LED_D3.0mm","Kingbright WP710A10ID","","D49 D77"
"2","red +18 dB","LED_THT:LED_D3.0mm","Kingbright WP710A10ID","","D50 D78"
"24","BAV199","Package_TO_SOT_SMD:SOT-23","Nexperia BAV199,215","","D79 D80 D81 D82 D83 D84 D85 D86 D87 D88 D89 D90 D91 D92 D93 D94 D95 D96 D97 D98 D99 D100 D101 D102"
"2","MF-RX250/72","goa-console:Fuse_Bourns_MF-RX250-72_Radial_P10.16mm","Bourns MF-RX250/72-0","","F1 F3"
"2","MF-RX185/72","goa-console:Fuse_Bourns_MF-RX185-72_Radial_P5.08mm","Bourns MF-RX185/72-0","","F2 F4"
"5","Ferrite 220R@100MHz","Inductor_SMD:L_0805_2012Metric","Murata BLM21PG221SN1D","","FB1 FB2 FB3 FB4 FB5"
"1","PSU in (NC7MD-LX)","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-1,5-7-5.08_1x07_P5.08mm_Horizontal","Phoenix 1755897 MKDS 1,5/7-5,08 (wired to a Neutrik NC7MD-LX inlet)","","J1"
"6","G6K-2F-Y DC12","Relay_SMD:Relay_DPDT_Omron_G6K-2F-Y","Omron G6K-2F-Y DC12","","K1 K2 K3 K4 K5 K6"
"1","MMBT3904","Package_TO_SOT_SMD:SOT-23","onsemi MMBT3904LT1G","","Q1"
"4","BCP53-16","Package_TO_SOT_SMD:SOT-223","onsemi BCP53-16T1G","","Q2 Q3 Q4 Q5"
"2","1R","Resistor_SMD:R_0805_2012Metric","Panasonic ERJ-P06J1R0V","","R1 R2"
"4","2R2","Resistor_SMD:R_2512_6332Metric","Vishay CRCW25122R20FKEGHP","","R3 R4 R130 R134"
"4","10R","Resistor_SMD:R_0805_2012Metric","","","R5 R6 R7 R8"
"15","4K7","Resistor_SMD:R_0805_2012Metric","","","R9 R33 R38 R49 R56 R59 R60 R67 R71 R78 R82 R104 R131 R135 R240"
"18","100K","Resistor_SMD:R_0805_2012Metric","","","R10 R31 R36 R66 R70 R77 R81 R102 R109 R111 R116 R119 R120 R121 R125 R126 R129 R133"
"2","4K7 1%","Resistor_SMD:R_0805_2012Metric","","","R11 R21"
"20","2K2 0.1%","Resistor_SMD:R_0805_2012Metric","Panasonic ERA-6AEB222V","","R12 R13 R14 R15 R22 R23 R24 R25 R62 R63 R64 R65 R73 R74 R75 R76 R98 R99 R100 R101"
"2","75R","Resistor_SMD:R_0805_2012Metric","Panasonic ERJ-P06J750V","","R16 R26"
"9","47K","Resistor_SMD:R_0805_2012Metric","","","R17 R20 R27 R30 R35 R40 R51 R94 R96"
"2","1K","Resistor_SMD:R_0805_2012Metric","","","R18 R28"
"2","75R","Resistor_SMD:R_0805_2012Metric","","","R19 R29"
"4","47R","Resistor_SMD:R_0805_2012Metric","","","R32 R37 R166 R203"
"4","2K2","Resistor_SMD:R_0805_2012Metric","","","R34 R39 R132 R136"
"20","10K","Resistor_SMD:R_0805_2012Metric","","","R41 R42 R43 R44 R45 R113 R115 R118 R123 R139 R140 R142 R143 R148 R176 R177 R179 R180 R185 R239"
"6","560R","Resistor_SMD:R_0805_2012Metric","","","R46 R47 R48 R127 R128 R137"
"1","56K","Resistor_SMD:R_0805_2012Metric","","","R50"
"3","22K","Resistor_SMD:R_0805_2012Metric","","","R52 R69 R80"
"1","64K9","Resistor_SMD:R_0805_2012Metric","","","R53"
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